# Keil uVision project optical_flow.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: optical_flow
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS,STM32F4XX,HSE_VALUE=8000000
  c include: .\inc;.\Libraries\CMSIS\Include;.\Libraries\Device\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32_USB_Device_Library\Class\cdc\inc;.\Libraries\STM32_USB_Device_Library\Core\inc;.\Libraries\STM32_USB_OTG_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f40_41xxx.s
  group Lib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USB
    ./User/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ./Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ./Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c i2c.c usart.c led.c systick.c MT9V034.c MT9D111.c camera_hw.c
